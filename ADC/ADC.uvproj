# Keil uVision project ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG_ENABLE_SEMIHOST
  group Source Group 1
    ./: STARTUP.A51 MCU_Config.h MCU_Common_Method.c MCU_Init.c MCU_Main.c MCU_Uart.c MCU_Timer.c MCU_ADC.c
