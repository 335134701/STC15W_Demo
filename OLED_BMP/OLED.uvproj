# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 MCU_Config.h OLED_Code.c OLED_Main.c OLED_Method.c MCU_Init.c MCU_Common_Method.c
