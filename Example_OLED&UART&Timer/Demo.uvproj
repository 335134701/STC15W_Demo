# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Default
    ./: STARTUP.A51
  group MCU_System
    ./: MCU_GPIO.c OLED_Code.c OLED_Method.c MCU_Uart.c MCU_Timer.c
  group MCU_Method
    ./: MCU_Main.c MCU_Init.c
